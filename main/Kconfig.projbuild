## main/Kconfig.projbuild
```kconfig
menu "Example Configuration"

    config EXAMPLE_LOGGING_TAG
        string "Default logging tag"
        default "DISTORT"

endmenu
```
